# Keil uVision project sig_bat_manage.uvprojx, settings and files
target sig_bat_manage (5060020::V5.06 (build 20)::ARMCC)
  device: LPC824M201JHI33 NXP
  pack: Keil.LPC800_DFP.1.2.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x10000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: sig_bat_manage +hex
  c flags: Optim=3 OneElfS=1 wLevel=2
  c include: .\code\board\include;.\code\include;.\code\app;.\code\drivers;.\code\common\include
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group app
    ./code/app/: main.c
  group board
    ./code/board/src/: am_lpc82x_adc.c am_lpc82x_int.c am_lpc82x_dma.c amhw_lpc82x_clk.c am_lpc82x_gpio.c amhw_lpc82x_iocon.c amhw_lpc82x_pint.c amhw_lpc82x_swm.c amhw_lpc82x_usart.c am_lpc82x_hwconfig_gpio.c
  group driver
    ./code/drivers/: drv_key.c drv_gpio.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
